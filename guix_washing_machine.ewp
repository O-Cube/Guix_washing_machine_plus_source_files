# IAR project guix_washing_machine.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1052DVL6B; GUIX_PXP_ENABLE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; SDK_I2C_BASED_COMPONENT_USED=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; azure-rtos/config; azure-rtos/guix/common/inc; azure-rtos/guix/ports/cortex_m7/iar/inc; azure-rtos/threadx/common/inc; azure-rtos/threadx/ports/cortex_m7/iar/inc; component/lists; component/serial_manager; component/uart; device; drivers; touchpanel; utilities; video; xip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT=1
  ILINK.IlinkOutputFile: guix_washing_machine.out
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; GUIX_PXP_ENABLE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; SDK_I2C_BASED_COMPONENT_USED=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; GUIX_PXP_ENABLE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; SDK_I2C_BASED_COMPONENT_USED=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA; TX_ENABLE_FPU_SUPPORT=1
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; GUIX_PXP_ENABLE; SDK_DEBUGCONSOLE_UART; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; SERIAL_PORT_TYPE_UART=1; GX_INCLUDE_USER_DEFINE_FILE; SDK_I2C_BASED_COMPONENT_USED=1; TX_INCLUDE_USER_DEFINE_FILE; FSL_RTOS_THREADX; MCUXPRESSO_SDK
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: as above
  group azure-rtos/binary/guix/cortex_m7/iar
    azure-rtos/binary/guix/cortex_m7/iar/: libguix.a
  group azure-rtos/binary/threadx/cortex_m7/iar
    azure-rtos/binary/threadx/cortex_m7/iar/: libthreadx.a
  group azure-rtos/config
    azure-rtos/config/: gx_user.h tx_user.h
  group azure-rtos/guix
    azure-rtos/guix/: LICENSE.txt LICENSED-HARDWARE.txt
  group azure-rtos/guix/common/inc
    azure-rtos/guix/common/inc/: gx_animation.h gx_api.h gx_binres_loader.h gx_button.h gx_canvas.h gx_circular_gauge.h gx_context.h gx_display.h gx_drop_list.h gx_icon.h gx_image_reader.h gx_line_chart.h gx_menu.h gx_multi_line_text_input.h gx_multi_line_text_view.h gx_numeric_pixelmap_prompt.h gx_numeric_prompt.h gx_pixelmap_prompt.h gx_progress_bar.h gx_prompt.h gx_radial_progress_bar.h gx_radial_slider.h gx_rich_text_view.h gx_screen_stack.h gx_scroll_wheel.h gx_scrollbar.h gx_single_line_text_input.h gx_slider.h gx_sprite.h gx_system.h gx_system_rtos_bind.h gx_text_input_cursor.h gx_tree_view.h gx_user_sample.h gx_utility.h gx_widget.h gx_window.h
  group azure-rtos/guix/ports/cortex_m7/iar/inc
    azure-rtos/guix/ports/cortex_m7/iar/inc/: gx_port.h
  group azure-rtos/threadx
    azure-rtos/threadx/: LICENSE.txt LICENSED-HARDWARE.txt
  group azure-rtos/threadx/common/inc
    azure-rtos/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group azure-rtos/threadx/ports/common
    azure-rtos/threadx/ports/common/: tx_initialize_low_level.c
  group azure-rtos/threadx/ports/cortex_m7/iar/inc
    azure-rtos/threadx/ports/cortex_m7/iar/inc/: tx_port.h
  group azure-rtos/threadx/ports/cortex_m7/iar/src
    azure-rtos/threadx/ports/cortex_m7/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h
  group evkbimxrt1050
    evkbimxrt1050/: evkbimxrt1050_sdram_init.mac
  group MIMXRT1052/iar
    MIMXRT1052/iar/: MIMXRT1052xxxxx_flexspi_nor_sdram.icf MIMXRT1052xxxxx_sdram.icf
  group source
    source/: garments.c guix_washing_machine.c guix_washing_machine.h gx_display_driver_imxrt10xx_24xrgb.c gx_display_driver_imxrt10xx_565rgb.c gx_driver_imxrt10xx_irq.c gx_touch_driver_imxrt10xx_capacitive.c sample_guix_washing_machine.gxp sample_guix_washing_machine_resources.c sample_guix_washing_machine_resources.h sample_guix_washing_machine_specifications.c sample_guix_washing_machine_specifications.h temperature.c washer_on.c water_level.c
  group source/fonts/verasans
    source/fonts/verasans/: Vera.ttf VeraBd.ttf VeraBI.ttf VeraIt.ttf
  group source/graphics
    source/graphics/: bg_garments.png bg_temperature.png bg_washer_on.png button.png button_garments_on.png button_icon_pause.png button_icon_power.png button_icon_sock.png button_icon_start.png button_icon_temperature.png button_icon_water_level.png button_pause_on.png button_power_on.png button_temperature_on.png button_water_level.png express_logic_logo.png guix-logo-vertical.png icon_sock.png icon_water_container.png menu_icon_home.png menu_icon_home_on.png progress_background.png progress_lower_fill.png progress_upper_fill.png slider_indicator_progress_bar.png slider_indicator_water_level.png target.png transparent_dot.png water_level_lower_fill.png water_level_upper_fill.png wheel_dot_blue.png wheel_dot_green.png wheel_dot_orange.png wheel_dot_red.png wheel_dot_yellow.png
  group startup
    startup/: startup_MIMXRT1052.s
  group touchpanel
    touchpanel/: fsl_ft5406_rt.c fsl_ft5406_rt.h fsl_gt911.c fsl_gt911.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group video
    video/: fsl_dc_fb.h fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h fsl_video_common.c fsl_video_common.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
